Commit message: change coordinates

File: assets/obstacles/block.urdf (robot description, URDF)
Before this commit: robot simple_cuboid, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.2 0.2 0.2; visual box size=0.2 0.2 0.2
